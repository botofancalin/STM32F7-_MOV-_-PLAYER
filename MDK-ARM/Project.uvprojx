# Keil uVision project Project.uvprojx, settings and files
target STM32746G-DISCOVERY (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.5.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G-DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCOVERY
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32746G-Discovery;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_fmc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sd.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/User
    ../Src/: stm32f7xx_it.c main.c decode.c MPEG.c my_waveplayer.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/BSP/STM32746G-DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_sdram.c stm32746g_discovery.c stm32746g_discovery_sd.c stm32746g_discovery_lcd.c stm32746g_discovery_audio.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Middlewares/Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jccolor.c jutils.c jdinput.c jctrans.c jidctint.c jccoefct.c jdcolor.c jquant2.c jdtrans.c jddctmgr.c jdsample.c jcdctmgr.c jcsample.c jaricom.c jdmaster.c jcapistd.c jdcoefct.c jidctfst.c jcmarker.c jdapimin.c jcmainct.c jmemmgr.c jcmaster.c jfdctflt.c jfdctfst.c jdarith.c jdmainct.c jerror.c jdmarker.c jdatasrc.c jchuff.c jcinit.c jcparam.c jidctflt.c jcprepct.c jquant1.c jdmerge.c jcapimin.c jdapistd.c jdhuff.c jcomapi.c jdpostct.c jcarith.c jdatadst.c jmemnobs.c jfdctint.c
software components: CMSIS:CORE 4.1.0
